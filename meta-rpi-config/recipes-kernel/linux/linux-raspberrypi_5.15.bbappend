FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://add_cfg_5.15.cfg"