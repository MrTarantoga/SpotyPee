FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://kernel_cfg.cfg"
