LINUX_VERSION = "6.1.58"
SRCREV_machine = "8dcc16f0adc50f5cb8a11a6dde238131d0ca45a0"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://add_cfg_6.1.cfg"
