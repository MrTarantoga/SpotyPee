FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://add_cfg.cfg"
